# Remove unsupported types
IMAGE_FSTYPES:remove = "wic wic.zst wic.bmap"
