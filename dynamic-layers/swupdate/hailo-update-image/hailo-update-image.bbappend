SWUPDATE_MMC_INDEX:hailo15-solidrun  = "1"

# sw-description templates @@SWUPDATE_DEFAULT_FILESYSTEM_DEVICE@@ -> Hailo EVK default is mmcblk0.
# we use eMMC mmcblk1.
SWUPDATE_DEFAULT_FILESYSTEM_DEVICE:hailo15-solidrun = "mmcblk1"
