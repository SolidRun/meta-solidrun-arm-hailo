addtask deploy after do_install
